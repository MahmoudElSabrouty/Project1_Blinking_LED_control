# Keil uVision project Project1_Blinking_LED_control.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project1_Blinking_LED_control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\COTS\COMMON;.\COTS\MCAL\Include;.\COTS\MCAL\Config;.\COTS\HAL;.\COTS\APPLICATION
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APPLICATION
    ./COTS/APPLICATION/: main.c APPL_MAIN.h
  group HAL
    ./COTS/HAL/: Port_Cfg.h Gpt_Cfg.h Bsp.h
  group MCAL
    ./COTS/MCAL/IntCtrl/: IntCtrl.c
    ./COTS/MCAL/Include/: IntCtrl_Types.h IntCtrl.h Dio.h Dio_Types.h Port.h Port_Types.h
    ./COTS/MCAL/Gpio/: Port.c Dio.c
    ./COTS/MCAL/Config/: IntCtrl_Cfg.h IntCtrl_Lcfg.c Port_Lcfg.c Gpt_Lcfg.c
    ./COTS/MCAL/Gpt/: Gpt.c
  group COMMON
    ./COTS/COMMON/: Compiler.h Mcu_Hw.h Platform_Types.h Std_Types.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
